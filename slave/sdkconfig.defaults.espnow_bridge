## slave/sdkconfig.defaults.espnow_bridge
```kconfig
CONFIG_ESP_HOSTED_ESPNOW_BRIDGE=y
CONFIG_ESP_HOSTED_ENABLE_PEER_DATA_TRANSFER=y
CONFIG_ESP_HOSTED_MAX_CUSTOM_MSG_HANDLERS=8
```
